Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-06-07T04:12:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 07 04:12:19 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\007666e1-a42d-453a-b422-61773be8eacf\31a8bfc3-adb4-42d4-882a-4f51b4739ffb\ifc * Database version: 5507 * Database creation date: Wed Jun 07 04:12:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 07 04:12:15 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 07 04:12:15 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Soft Work - Platform 1-seater, double, Vitra-Sofas-Soft_Work-1-seater-Platform-Double_rfa:Soft Work - Platform 1-seater, double:350512
In: Level 1
Type - Material: Basic dark powder-coated 30, Dark grey 69, Polished Aluminium
Type - Constraints - Default Elevation: 0 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Sofas-Soft_Work-1-seater-Platform_Double_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_81; Uniclass2015Description: Sofas; Uniclass2015Reference: Pr_40_50_12_81; Version: 1; VersionDate: 23/06/2023
Type - Identity Data - Cost: 0; Manufacturer: Vitra; Model: Soft Work - Platform 1-seater, double; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Soft Work - Platform 1-seater, double
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Sofas-Soft_Work-1-seater-Platform-Double_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Soft_Work-1-seater-Platform_Double_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 800x1300x870 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Soft_Work-1-seater-Platform_Double_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Soft Work - Platform 1-seater, double
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Construction - BaseType_LeftControl: Soft-Work_Base_Full; BaseType_RightControl: Soft-Work_Base_Full; LegVisibility: yes
Dimensions - Area: 1.99294 m2; Volume: 0.474652 m3
Materials and Finishes - BaseMaterial: Basic dark powder-coated 30; CoverMaterial: Dark grey 69; SurfaceMaterial: Polished Aluminium; TableTopMaterial: Basic dark powder-coated 30
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Sofas-Soft_Work-1-seater-Platform-Double_rfa: Soft Work - Platform 1-seater, double; Family and Type: Vitra-Sofas-Soft_Work-1-seater-Platform-Double_rfa: Soft Work - Platform 1-seater, double; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Sofas-Soft_Work-1-seater-Platform-Double_rfa: Soft Work - Platform 1-seater, double; Type Id: Vitra-Sofas-Soft_Work-1-seater-Platform-Double_rfa: Soft Work - Platform 1-seater, double; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
